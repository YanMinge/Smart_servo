# Keil uVision project Neuron.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: M058ZDN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.8
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Neuron +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Library\CMSIS\Include;..\Library\Device\Nuvoton\M051Series\Include;..\Library\StdDriver\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Neuron
    ../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
  group src
    ./: startup_M051Series.s
    ../src/: uart_printf.c main.c systime.c mygpio.c MePwm.c protocol.c Interrupt.c sysinit.c dataflash.c smartservo.c mp9960.c
  group inc
    ../inc/: uart_printf.h systime.h mygpio.h protocol.h Interrupt.h sysinit.h dataflash.h smartservo.h mp9960.h
  group Library
    ../inc/: MePwm.h
    ../Library/StdDriver/src/: retarget.c sys.c uart.c i2c.c timer.c clk.c gpio.c fmc.c pwm.c spi.c
