# Keil uVision project app_tft_display.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: M0516LAN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.6
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: app_tft_display +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\block_driver;..\..\common_utils;..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\M051Series\Include;..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../Library/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../../Library/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group block_driver
    ../../block_driver/: Me7SegmentDisplay.c Me7SegmentDisplay.h MeDCMotor.c MeDCMotor.h MeDht11.c MeDht11.h MeInfraredReceiver.c MeInfraredReceiver.h MeInfraredSend.c MeInfraredSend.h MeLedChain.c MeLedChain.h MeMPU6050.c MeMPU6050.h MeNumericDisplay.c MeNumericDisplay.h MePwm.c MePwm.h MeRgbLed.c MeRgbLed.h MeStepMotor.c MeStepMotor.h MeTemperature.c MeTemperature.h MeUltrasonicSensor.c MeUltrasonicSensor.h servo.c servo.h MeTftDisplay.h MeTftDisplay.c MeTftFontLib.h
  group common_utils
    ../../common_utils/: dataflash.c dataflash.h Interrupt.c Interrupt.h mygpio.c mygpio.h protocol.c protocol.h sysinit.c sysinit.h systime.c systime.h uart_printf.c uart_printf.h
  group std_driver
    ../../Library/StdDriver/src/: acmp.c adc.c clk.c ebi.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group app
    ./: main.c
