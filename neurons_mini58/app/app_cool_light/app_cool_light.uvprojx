# Keil uVision project app_cool_light.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: Mini58ZDE Nuvoton
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: app_cool_light +hex
  AfterMake: copy_hex.bat
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\common_utils;..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\Mini58Series\Include;..\..\Library\StdDriver\inc;..\..\block_driver
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group app
    ./: main.c
  group common_utils
    ../../common_utils/: Interrupt.c Interrupt.h mygpio.c mygpio.h protocol.c protocol.h sysinit.c sysinit.h systime.c systime.h uart_printf.c uart_printf.h
  group std_driver
    ../../Library/StdDriver/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group CMSIS
    ../../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
    ../../Library/Device/Nuvoton/Mini58Series/Source/ARM/: startup_Mini58Series.s
  group block_driver
    ../../block_driver/: MeCoolLight.c MeCoolLight.h
