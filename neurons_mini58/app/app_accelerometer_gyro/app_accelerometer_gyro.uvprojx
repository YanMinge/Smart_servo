# Keil uVision project app_accelerometer_gyro.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: M0516LAN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.6
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: app_accelerometer_gyro +hex
  AfterMake: copy_hex.bat
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\block_driver;..\..\common_utils;..\..\Library\CMSIS\Include;..\..\Library\StdDriver\inc;..\..\Library\Device\Nuvoton\Mini58Series\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
    ../../Library/Device/Nuvoton/Mini58Series/Source/ARM/: startup_Mini58Series.s
  group block_driver
    ../../block_driver/: MeMPU6050.c MeMPU6050.h
  group common_utils
    ../../common_utils/: Interrupt.c Interrupt.h mygpio.c mygpio.h protocol.c protocol.h sysinit.c sysinit.h systime.c systime.h uart_printf.c uart_printf.h
  group std_lib
    ../../Library/StdDriver/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group app
    ./: main.c
