# Keil uVision project app_self_locking_switch.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: Mini58ZDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.6
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: app_self_locking_switch +hex
  AfterMake: copy_hex.bat
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: D_SELF_LOCKING_SWITCH
  c include: ..\..\common_utils;..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\Mini58Series\Include;..\..\Library\Device\Nuvoton\Mini58Series\Include;..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group app
    ../../common_app/app_single_logic_input/: main.c
  group CMSIS
    ../../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
    ../../Library/Device/Nuvoton/Mini58Series/Source/ARM/: startup_Mini58Series.s
  group common_utils
    ../../common_utils/: Interrupt.c Interrupt.h mygpio.c mygpio.h protocol.c protocol.h sysinit.c sysinit.h systime.c systime.h uart_printf.c uart_printf.h
  group std_dirver
    ../../Library/StdDriver/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
