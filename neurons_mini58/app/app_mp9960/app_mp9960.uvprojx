# Keil uVision project app_mp9960.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: Mini58ZDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.8
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: app_mp9960 +hex
  AfterMake: E:\2016\智能舵机\其它模块\neurons_mini58\app\app_mp9960\copy_hex.bat
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output E:\2016\智能舵机\其它模块\neurons_mini58\app\app_mp9960\Objects\app_mp9960.bin  E:\2016\智能舵机\其它模块\neurons_mini58\app\app_mp9960\Objects\app_mp9960.axf
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\..\block_driver;..\..\common_utils;..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\Mini58Series\Include;..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/Mini58Series/Source/ARM/: startup_Mini58Series.s
    ../../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
  group common_utils
    ../../common_utils/: Interrupt.c protocol.c mygpio.c sysinit.c systime.c uart_printf.c block_param.h Interrupt.h mygpio.h protocol.h sysinit.h systime.h uart_printf.h
  group std_driver
    ../../Library/StdDriver/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group app
    ./: main.c
  group block_driver
    ../../block_driver/: mp9960.c mp9960.h
