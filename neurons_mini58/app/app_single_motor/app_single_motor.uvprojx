# Keil uVision project app_single_motor.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: Mini58ZDE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.6
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: app_single_motor +hex
  AfterMake: F:\work\neurons\BareCode_split\neurons_mini58\app\app_single_motor\copy_hex.bat
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: D_SINGLE_MOTOR
  c include: ..\..\block_driver;..\..\common_utils;..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\Mini58Series\Include;..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
    ../../Library/Device/Nuvoton/Mini58Series/Source/ARM/: startup_Mini58Series.s
  group app
    ./: main.c
  group block_driver
    ../../block_driver/: MeDCMotor.c MeDCMotor.h
  group std_driver
    ../../Library/StdDriver/src/: acmp.c adc.c clk.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group common_utils
    ../../common_utils/: block_param.h Interrupt.c Interrupt.h mygpio.c mygpio.h protocol.c protocol.h sysinit.c sysinit.h systime.c systime.h uart_printf.c uart_printf.h
